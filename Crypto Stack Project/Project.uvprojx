# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\CryIf;.\Crypto Driver;.\CSM;..\Crypto Stack Project;.\mbedtls\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group mbedtls
    ./mbedtls/library/: aes.c platform_util.c sha256.c
  group Source Group
    ./CryIf/: CryIf.c
    ./Crypto Driver/: Crypto.c
    ./CSM/: Csm.c
    ./: main.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
